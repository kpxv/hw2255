# Keil uVision project lab2.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL03Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFFE00,0x00000800) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lab2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffe00 size 0x800
  group Source Group 1
    ./work/: lab2.s
